Commit message: added single contact sensor - champ

File: champ_description/urdf/champ3.urdf (robot description, URDF)
Before this commit: robot champ, 29 links, 28 joints
Links:
- link lf_foot_link: mass 0.001 -> None; geometry 
